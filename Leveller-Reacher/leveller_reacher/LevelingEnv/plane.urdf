Commit message: Update plane.urdf

File: Leveller-Reacher/leveller_reacher/LevelingEnv/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- removed link base_link
- added link base, mass 0; collision box size=20 20 0.01; visual box size=20 20 0.01
